# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Project +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\Project
  group Source Group 1
    ../: main.c LED_stripe.c
  group Library
    ../../../../Library/StdDriver/src/: putchar.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
